Commit message: Fase 2 completed with correct plots

File: practica 1/FASE_2/bar.urdf (robot description, URDF)
Before this commit: robot bar, 2 links, 1 joints
Joints:
- joint base_to_body: origin xyz=0 0 0.02 -> xyz=0 0 0.14493
